## work/debug/android/hello/Kconfig
```kconfig
config HELLO
       tristate "A Android test Driver"
       default n
       help
         This is a Android test Driver
```
